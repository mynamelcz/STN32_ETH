# Keil uVision project ETH_LAN8720.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ETH_LAN8720
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\HalLib\CMSIS\Include;..\HalLib\CMSIS\Device\ST\STM32F4xx\Include;..\HalLib\STM32F4xx_StdPeriph_Driver\inc;..\HalLib\STM32F4x7_ETH_Driver\inc;..\Bsp\inc;..\Main\inc;..\Main;..\Dev\LAN8720;..\ThridPart\LwIP_1_4_1\src\include;..\ThridPart\LwIP_1_4_1\src\include\lwip;..\ThridPart\LwIP_1_4_1\src\include\netif;..\ThridPart\LwIP_1_4_1\src\include\ipv4;..\ThridPart\LwIP_1_4_1\lwip_app;..\ThridPart\LwIP_1_4_1\src\arch
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Core
    ../HalLib/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../HalLib/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group User
    ../Main/: main.c stm32f4xx_it.c
  group FWLIB
    ../HalLib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_syscfg.c
    ../HalLib/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group Bsp
    ../Bsp/src/: bsp_uart.c bsp_timer.c
  group Dev
    ../Dev/LAN8720/: LAN8720.c
  group LwIP_APP
    ../ThridPart/LwIP_1_4_1/lwip_app/: lwip_init.c lwip_tcp_server.c lwip_ping.c lwip_udp.c tftp_udp.c
  group LwIP_Core
    ../ThridPart/LwIP_1_4_1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../ThridPart/LwIP_1_4_1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LwIP_NETIF
    ../ThridPart/LwIP_1_4_1/src/netif/: etharp.c ethernetif.c
  group LwIP_ARCH
    ../ThridPart/LwIP_1_4_1/src/arch/: sys_arch.c
